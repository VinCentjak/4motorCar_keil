# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Driver\STM32F1XX_HAL_Driver\Inc;..\..\Driver\CMSIS\Include;..\..\Users;..\..\Driver\CMSIS\Device\ST\STM32F1xx\Include;..\..\Middlewares;..\..\Driver;..\..\Driver\SYSTEM\delay;..\..\Driver\SYSTEM\sys;..\..\Driver\SYSTEM\usart;..\..\Driver\FreeRTOS\include;..\..\Driver\FreeRTOS\port\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Users
    ../../Users/: stm32f1xx_it.c main.c FreeRTOSConfig.h
    ../../Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Driver/SYSTEM
    ../../Driver/SYSTEM/delay/: delay.c delay.h
    ../../Driver/SYSTEM/sys/: sys.c
    ../../Driver/SYSTEM/usart/: usart.c
  group Driver/STM32F1xx_HAL_Driver
    ../../Driver/STM32F1XX_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c
    ../../Driver/STM32F1XX_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_i2c.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_spi.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_dma.h
  group FreeRTOS/inc
    ../../Driver/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/src
    ../../Driver/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../Driver/FreeRTOS/port/MemMang/: heap_4.c
    ../../Driver/FreeRTOS/port/RVDS/ARM_CM3/: port.c portmacro.h
